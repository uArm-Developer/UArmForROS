Commit message: Update model.urdf

File: urdf/model.urdf (robot description, URDF)
Before this commit: robot firefighter, 11 links, 10 joints
Links:
- link base: geometry visual mesh filename=package://uarm/urdf/daes/base.STL
